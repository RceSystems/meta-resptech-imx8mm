FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001_GPIO_script.patch \
            file://0002_Switch_Devicetree.patch"
